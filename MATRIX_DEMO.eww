<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pdu\libproj\PDU_CORE.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\iar\MATRIX_DEMO.ewp</path>
    </project>
    <batchBuild />
</workspace>
