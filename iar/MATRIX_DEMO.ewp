# IAR project MATRIX_DEMO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F40_41xxx
  ICCARM.CCIncludePath2: ..\core; ..\user; ..\rtt; ..\pdu
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MATRIX_DEMO.bin
  ILINK.IlinkOutputFile: STM32F407Project_Test.out
  ILINK.IlinkIcfFile: D:\codicis\CODING\pwrmatrix_demo\iar\config\pdu.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../pdu/libproj/Debug/Exe/: PDU_CORE.a
  group core
    ../core/: system_stm32f4xx.c
  group rtt
    ../rtt/: SEGGER_RTT.c SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group startup
    ../startup/: startup_stm32f40_41xxx.s
  group user
    ../user/: pdu_cli.c pdu_main.c
