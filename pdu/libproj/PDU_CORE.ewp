# IAR project PDU_CORE.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F40_41xxx
  ICCARM.CCIncludePath2: ..\..\core; ..\..\user
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ESPCU_dbstd.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\core; ..\fwlib\inc; ..\user
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: ESPCU_dbstd.srec
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: pdu_broker.c pdu_demon.c pdu_tactic.c
